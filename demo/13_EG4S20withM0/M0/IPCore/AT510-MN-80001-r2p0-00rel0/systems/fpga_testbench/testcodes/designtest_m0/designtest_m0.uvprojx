# Keil uVision project designtest_m0.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: designtest_m0
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L -c -d -e -s --output designtest_m0.lst
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --64x1 --output designtest_m0.hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M0 ARDUINO_SUPPORT
  c include: ..\..\..\..\software\cmsis\CMSIS\Include;..\..\..\..\software\cmsis\Device\ARM\CMSDK_CM0\Include;..\..\..\..\software\common\retarget;..\..\..\..\software\common\fpga_defs
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group Startup
    ../../../../software/cmsis/Device/ARM/CMSDK_CM0/Source/ARM/: startup_CMSDK_CM0.s
  group Application
    ../../../../software/common/retarget/: retarget.c uart_stdout.c
    ../../../../software/cmsis/Device/ARM/CMSDK_CM0/Source/: CMSDK_driver.c
    ./: designtest_m0.c apaaci.c apaaci_i2c.c
  group System
    ../../../../software/cmsis/Device/ARM/CMSDK_CM0/Source/: system_CMSDK_CM0.c
