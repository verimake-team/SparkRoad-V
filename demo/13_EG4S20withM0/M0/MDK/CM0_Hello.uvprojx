# Keil uVision project CM0_Hello.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CM0_Hello
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src
  memory RVCT4: ROM 0x0 size 0x3fff
  memory RVCT9: RAM 0x20000000 size 0x3fff
  group driver
    ./src/: main.c gpio.c UART.c systick.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
